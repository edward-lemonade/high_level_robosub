Commit message: implemented twist controls that dont work

File: urdf/exact_robosub.urdf (robot description, URDF)
Before this commit: robot URDF robosub, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1 1 1; visual mesh filename=base_link.STL
