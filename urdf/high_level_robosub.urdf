Commit message: vm

File: urdf/high_level_robosub.urdf (robot description, URDF)
Before this commit: robot block_6dof, 1 links, 0 joints
Links:
- link block_link: mass 1.0 -> 1000.0; geometry collision box size=1 1 1; visual box size=1 1 1
